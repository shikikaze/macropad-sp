# Repository shikikaze/macropad-sp

File README.md:

# Macropad (school project)

(This project has been put on hold for a bit, but the PCB files are more or less finished.)

12+1 key macropad with an encoder, built using QMK and VIA.

## KiCad design KiCadPCB/KiCadPCB.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2: MountingHole; MountingHole_3.2mm_M3
SW1: M1; SW_Cherry_MX_1.00u_PCB
SW2: M2; SW_Cherry_MX_1.00u_PCB
SW3: M3; SW_Cherry_MX_1.00u_PCB
SW4: M4; SW_Cherry_MX_1.00u_PCB
SW5: M5; SW_Cherry_MX_1.00u_PCB
SW6: M6; SW_Cherry_MX_1.00u_PCB
SW7: M7; SW_Cherry_MX_1.00u_PCB
SW8: M8; SW_Cherry_MX_1.00u_PCB
SW9: M9; SW_Cherry_MX_1.00u_PCB
SW10: M10; SW_Cherry_MX_1.00u_PCB
SW11: M11; SW_Cherry_MX_1.00u_PCB
SW12: M12; SW_Cherry_MX_1.00u_PCB
SW13: M13; SW_Cherry_MX_1.00u_PCB
SW14: ENCODER; RotaryEncoder_Alps_EC12E-Switch_Vertical_H20mm
U1: ProMicro; ProMicro-NoSilk

Connections:
+5V: U1.21
/COL0: D14.1 (K), SW7.1, U1.19
/COL1: SW1.1, SW8.1, U1.18
/COL2: SW2.1, SW9.1, U1.17
/COL3: SW3.1, SW10.1, U1.16
/COL4: SW4.1, SW11.1, U1.15
/COL5: SW5.1, SW12.1, U1.14
/COL6: SW6.1, SW13.1, U1.13
/ROW0: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), SW14.S1, U1.11
/ROW1: D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), U1.12
GND: SW14.C, U1.3, U1.4, U1.23
unnamed: D1.1 (K), SW1.2
unnamed: D2.1 (K), SW2.2
unnamed: D3.1 (K), SW3.2
unnamed: D4.1 (K), SW4.2
unnamed: D5.1 (K), SW5.2
unnamed: D6.1 (K), SW6.2
unnamed: D7.1 (K), SW7.2
unnamed: D8.1 (K), SW8.2
unnamed: D9.1 (K), SW9.2
unnamed: D10.1 (K), SW10.2
unnamed: D11.1 (K), SW11.2
unnamed: D12.1 (K), SW12.2
unnamed: D13.1 (K), SW13.2
unnamed: D14.2 (A), SW14.S2
unnamed: SW14.A, U1.8
unnamed: SW14.B, U1.7

Board: 2 copper layers, 152.4 x 48.9 mm, 31 parts (0 on the bottom side), 26 nets.

## Commit log

2021-09-11 Updated the block diagram with explanation.
2021-09-11 Added the Visio file for the block diagram
2021-09-13 created basi cBOM
2021-09-13 updated the BOM
2021-09-13 Added QMK firmware
2021-09-13 Renamed
2021-09-13 copied over QMK firmware files
2021-09-13 updated the config a bit
2021-09-13 Updated rules.mk
2021-09-13 did some shit idk anymore
2021-09-13 added todo, added PCB files
2021-09-13 Added PCB files
2021-09-14 Updated the schematic
2021-09-14 Updated the PCB schematic.
2021-09-14 Updated the schematic, which should now be finished.
2021-09-28 Updated the Visio block diagram
2021-09-28 Posodobil opis delovanja
2021-10-01 Deleted the old PCB files that aren't needed anymore.
2021-10-01 Added new PCB files and moved footprint symbols
2021-10-01 Removed files that are irrelevant to the current progress
2021-10-02 Update README.md
    Updated readme
2021-10-02 Started working on the schematic
2021-10-02 Added gerber files and updated the PCB files.
2021-10-16 Updated readme.
2021-12-19 Updated the PCB file as the last prototype revision
2021-12-19 Updated gerber files and PCB files to include things needed for production.
2021-12-20 updated firmware to a0, To Be Tested
2022-01-18 Updated the PCB files to have supports in the top right section - pressing the encoder causes the macropad to tip over.
2022-01-18 Updated the PCB files for the new KiCad version, and changed the positioning of the standoff screwholes to better support the PCB when the encoder is being pressed.
2022-01-18 Removed the edge cuts where the USB connector is on the promicro.
